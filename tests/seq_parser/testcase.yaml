## tests/seq_parser/testcase.yaml
```yaml
tests:
  seq_parser:
    tags: parser
    platform_allow: native_posix
    integration_platforms:
      - native_posix
```
